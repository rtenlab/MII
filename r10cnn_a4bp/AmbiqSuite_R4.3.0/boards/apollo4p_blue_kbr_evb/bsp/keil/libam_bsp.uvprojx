# Keil uVision project libam_bsp.uvprojx, settings and files
target libam_bsp (6190000::V6.19::ARMCLANG)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.0
  cpu: IROM(0x00018000,0x0001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_bsp (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AM_PACKAGE_BGA DISP_CFG DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_8 AM_PART_APOLLO4P B_USE_DPHYPLL=true DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X12 DISP_TYPE=RM67162_DSI NUM_LANES=1 keil
  c include: ../../../../mcu/apollo4p;../../../../devices;../../../../utils;../../../../CMSIS/AmbiqMicro/Include;../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group source_files
    ../: am_bsp.c am_bsp_pins.c
