# Keil uVision project r10cnn_a4bp.uvprojx, settings and files
target r10cnn_a4bp (6190000::V6.19::ARMCLANG)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: r10cnn_apollo4p_evb
  AfterMake: fromelf --bin --output bin\r10cnn_apollo4p_evb.bin bin\r10cnn_apollo4p_evb.axf
  AfterMake: fromelf -cedrst --output bin\r10cnn_apollo4p_evb.txt bin\r10cnn_apollo4p_evb.axf
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AM_PACKAGE_BGA  AM_FREERTOS AM_PART_APOLLO4P keil AM_UTIL_FAULTISR_PRINT UART_PROFILE
  c include: ..\AmbiqSuite_R4.3.0;..\AmbiqSuite_R4.3.0\utils;..\AmbiqSuite_R4.3.0\CMSIS\ARM\Include;..\AmbiqSuite_R4.3.0\mcu\apollo4p;..\AmbiqSuite_R4.3.0\CMSIS\AmbiqMicro\Include;..\AmbiqSuite_R4.3.0\boards\apollo4p_evb\bsp;..\src;..\AmbiqSuite_R4.3.0\devices;..\src\r10_FreeRTOS\Source\include;..\src\r10_FreeRTOS\Source\portable\Keil6\AMapollo4
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../AmbiqSuite_R4.3.0/mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c r10_cnn.c r10cnn_conv_layers.c r10cnn_core_layers.c r10cnn_pool_layers.c r10cnn_utils.c r10cnn_rtos.c a4p_hardware.c r10cnn_offline1.c
  group keil
    ../keil/: startup_keil.s
  group libs
    ../AmbiqSuite_R4.3.0/boards/apollo4p_evb/bsp/keil/bin/: libam_bsp.lib
    ../AmbiqSuite_R4.3.0/mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
  group utils
    ../AmbiqSuite_R4.3.0/utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group r10_FreeRTOS
    ../src/r10_FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../src/r10_FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../src/r10_FreeRTOS/Source/portable/Keil6/AMapollo4/: port.c
